<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="35239A01-60DF-4757-A3C6-AF8C627806DA">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B917CE42-3BF6-4749-BDEC-D6197891DD1F">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D39D3055-69A7-4A5C-93FA-4667C8F30AD2">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DBC19ACD-E5EB-46B7-8E88-02E28EC1B99A">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6CBEA8D2-FC2E-46FD-8FC8-EC65A2453952">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AE9F4BF4-E8F4-4AB2-B4A0-F1FBBF1A85B9">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="20F7319E-24A0-4237-9EDD-112B6A353BB7">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A91E895A-F449-4BA4-BB39-43467A40E75F">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="595723BD-2869-4AA6-8CD2-9C1C31C23AF4">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="88B58CD1-B63F-4E29-B58D-5D80A3B6A2EF">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="2F4585E8-EF9A-4C99-86DB-16884781810A">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FBB4DD1A-4D68-45B4-AF26-09A29CC9C314">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="7E0E1D59-EA1B-4E17-A1A5-6FE4964E88DD">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8F62F6D7-5702-4285-BAD3-F73CFFBF7194">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="17B47093-2579-450F-9051-4F6566B79405">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A515D5C6-647F-406D-8F6E-3679802738F8">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="93351EE6-1B72-4948-8CEE-D8FB30B61F3A">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="268273E8-7FEA-4EFC-B0DD-BA70B970D352">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="1D5FE0B2-B292-40BC-8587-61024BDDCF69">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C00F359E-A1D6-413E-B3A2-9DEE82369F56">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0276A866-85D8-4050-B89D-D49853A4A69C">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="2F99517A-01CE-4E1B-8F67-52AAC4E5D623">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="6B46E310-03C8-408F-A0FC-2B6BD10339E7">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="F390B75D-D09B-41A2-8B67-BFB4F3C9C58B">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E0C9AAFC-4937-48A0-A65D-606B27A6BD20">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="FC4953C3-DD13-46B7-A290-37313AF81495">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="AB7D9640-7AFD-4323-80D0-1270E167E3C1">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="054A09F3-CF03-479F-AFF7-7C2198F11B70">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DCAC5047-E29C-4C9C-A276-BCFA87780688">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>